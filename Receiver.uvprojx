# Keil uVision project Receiver.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Transmitter
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: .\src\inc;.\src\driverlib
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Driver Library
    ./src/driverlib/rvmdk/: driverlib.lib
  group New Group
    D:/李响/Documents/University/大二下/工科创II/A2000TM4/DigitalMusicTransmitter-Receiver/src/: ASynthesis.c initialization.c note.c scoreRec.c transmitter.c
    ./src/: scMyChineseHeart.c scoreBuf.c UARTui.c
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.0
